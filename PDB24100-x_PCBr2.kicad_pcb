# Repository zer0ohm/PDB

File README.md:

# PDB
Mini powersupply powered by USB-PD adapter or battery

## misc
[Kicanvas(Preview KiCad design file on web)](https://kicanvas.org/?github=https://github.com/zer0ohm/PDB/blob/schv3_pcbr2/PDB24100-x_PCBr2.kicad_pcb)

## KiCad design PDB24100-x_PCBr2.kicad_pcb

Parts:
C102, C204: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN GRM188C81E105KA12; LCSC.PN C469535
C201, C210: 470u; CP_Radial_D10.0mm_P5.00mm; MPN 35ZLH470MEFC10X16; LCSC.PN C338196
C202: 10u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder; MPN GRM32ER71H106KA12; LCSC.PN C576517
C203, C209: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN GRM188R72A104KA35D; LCSC.PN C77055
C205, C207: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN GRM188R11H102KA01; LCSC.PN C77026
C208: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; MPN GCM1885C2A471JA16D; LCSC.PN C184771
CN101: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; MPN USB4105-GF-A; LCSC.PN C2760486
CN301: B5P-VH; JST_VH_B5P-VH-B_1x05_P3.96mm_Vertical; MPN B5P-VH(LF)(SN); LCSC.PN C160318
CN302: B3B-PH-K; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical; MPN B3B-PH-K-S(LF)(SN); LCSC.PN C131339
D101: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; MPN SML-E12P8WT86; LCSC.PN C126319
D201: RBR20BM40AFH; TO-252-Handsoldering; MPN RBR20BM40AFHTL; LCSC.PN C5336538
F101: 3557-15; FUSE_3557-15; MPN 3557-15; LCSC.PN C3207044
FN301: GDA5020; MPN GDA5020
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
L201: 15uH; SRP1265CC; MPN SRP1265CC-150M; LCSC.PN C18337515
Q201: RD3G03BBG; TO-252-Handsoldering; MPN RD3G03BBGTL1
Q301: 2N7002K; SOT-23_Handsoldering; MPN 2N7002K_R1_00501; LCSC.PN C7461930
R101, R102: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD5101F; LCSC.PN C105580
R103, R208: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD1001F; LCSC.PN C22548
R104: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD2003F; LCSC.PN C105574
R105: 3.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD3601F; LCSC.PN C137729
R201: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD7501F; LCSC.PN C114634
R203, R205, R302, R303: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD1003F; LCSC.PN C14675
R204, R301: 4.7R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD4R70F; LCSC.PN C137705
R206, R207: 0.1R; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder; MPN RCWE1210R100FKEA; LCSC.PN C2094571
R209: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD4701F; LCSC.PN C99782
R210: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD1000F; LCSC.PN C139043
R211: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73H1JTTD4702F; LCSC.PN C105579
R212: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; MPN RK73Z1JTTD; LCSC.PN C130238
RV201: 1k; Potentiometer_TOCOS_GF063P; MPN GF063P B102K
TP1: RTCT; TestPoint_Pad_D1.5mm
TP2: COMP; TestPoint_Pad_D1.5mm
TP3: VFB; TestPoint_Pad_D1.5mm
TP4: SENSE; TestPoint_Pad_D1.5mm
TP5: PWRFET_G; TestPoint_Pad_D1.5mm
TP6: GND; TestPoint_Pad_D2.5mm
U101: CH221K; SOT-23-6_Handsoldering; MPN CH221K
U201: LM3843; SO-8_3.9x4.9mm_P1.27mm; MPN LM3843AD(HTC); LCSC.PN C702405

Connections:
+24V: C209.1, C210.1, CN301.1, CN301.2, D201.2 (K), R211.2
/CC1: CN101.A5 (CC1), R101.1, U101.4 (CC1)
/CC2: CN101.B5 (CC2), R102.2, U101.5 (CC2)
/COMP: C207.2, R203.1, TP2.1, U201.1 (COMP)
/FAN_EN: CN302.3, R301.1
/ISENSE: C208.1, R208.1, TP4.1, U201.3 (ISENSE)
/OUT: R204.1, U201.6 (OUTPUT)
/RC: C205.1, R201.1, TP1.1, U201.4 (RT/CT)
/VFB: C207.1, R203.2, R212.1, RV201.1, RV201.2, TP3.1, U201.2 (VFB)
/VREF: C204.1, R201.2, U201.8 (VREF)
GND: C102.2, C201.2, C202.2, C203.2, C204.2, C205.2, C208.2, C209.2, C210.2, CN101.A1 (GND), CN101.A12 (GND), CN101.B1 (GND), CN101.B12 (GND), CN101.S1 (SHIELD), CN301.3, CN301.4, CN301.5, Q301.2 (S), R101.2, R102.1, R205.1, R206.1, R207.1, R210.1, R302.1, TP6.1, U101.2 (GND), U201.5 (GND)
unnamed: CN302.2, Q301.3 (D)
unnamed: D101.2 (A), R105.2
unnamed: D101.1 (K), U101.3 (PowerGood)
unnamed: JP1.1 (A), R302.2
unnamed: JP1.3 (B), R303.1
unnamed: JP1.2 (C), Q301.1 (G), R301.2
unnamed: D201.1 (A), D201.3 (A), L201.2, Q201.2 (D)
unnamed: Q201.1 (G), R204.2, R205.2, TP5.1
unnamed: Q201.3 (S), R206.2, R207.2, R208.2
unnamed: R209.1, R210.2
unnamed: R209.2, RV201.3
unnamed: R211.1, R212.2
unnamed: R104.2, U101.6 (CFG)
unnamed: C102.1, R103.2, R104.1, U101.1 (VDD)
VCC: C201.1, C202.1, C203.1, CN302.1, F101.2, L201.1, R103.1, R105.1, R303.2, U201.7 (VCC)
VDC: CN101.A4 (VBUS), CN101.A9 (VBUS), CN101.B4 (VBUS), CN101.B9 (VBUS), F101.1

Notes on the sheet:
9 V
注: 使用するチップ抵抗の許容誤差はすべて±1%
5 V
R104
20k
Vout
35V
合成抵抗Rb
CN302 Pin1: DCファンの+端子 Pin2: DCファンの-端子 Pin3: ENABLE(外部信号でON/OFF)
100k
15 V
DC_FAN
発振周波数設定 Fosc = (1.72) / ( (R201) * (C205) ) = (1.72) / ( (7500) * (1000*10^-12) ) = 229333.333333[Hz] ≒ 229.33[kHz]
出力電圧範囲: 22.7V～26.9[V] フィードバック抵抗 Vout = Vvfb(1 + ( (R211+R212) / (RV201+R209+R210) ) ) = 2.5(1 + ( (47000+0) / (1000+4700+100) ) ) = 22.758[V]
50V
25V
12 V
OUTPUT
発振周波数設定
JP1 1～2ピン間をショート: プルダウン 2～3ピン間をショート: プルアップ(常時冷却モード)
10k
200k
fuse: 0891005.NXS
VDC=20V
20 V
47k
合成抵抗Ra

Board: 4 copper layers, 50.0 x 50.0 mm, 52 parts (3 on the bottom side), 27 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm_M3_DIN965

## Commit log

2024-04-12 Add files via upload
    beta release
2024-04-12 Create CHANGELOG.md
    改版履歴を追加
2024-08-21 Update README.md
    Add link to kicanvas.org
